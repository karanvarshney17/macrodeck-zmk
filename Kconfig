## Kconfig
```kconfig
config MACRODECK_POWER_STATUS
	bool "Macrodeck: report USB power (charging) over Bluetooth"
	default y
	depends on ZMK_BLE && ZMK_USB
```
